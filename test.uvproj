# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: test +hex
  group source
    ./: main.c disp1602.c common.c disp128_64.c ISR.asm i2c.c mpu6050.c
  group header
    ./: common.h disp1602.h pic.h disp128_64.h i2c.h mpu6050.h
